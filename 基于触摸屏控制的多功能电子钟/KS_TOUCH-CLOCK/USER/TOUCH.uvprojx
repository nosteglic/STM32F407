# Keil uVision project TOUCH.uvprojx, settings and files
target TOUCH (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: TOUCH +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\USMART;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\SDIO;..\HARDWARE\SPI;..\HARDWARE\SRAM;..\HARDWARE\TOUCH;..\HARDWARE\TPAD;..\HARDWARE\W25QXX;..\HARDWARE\RTC;..\GUI;..\MALLOC;..\PICTURE;..\TEXT;..\HARDWARE\BEEP;..\FATFS\exfuns;..\FATFS\src;..\APP;..\HARDWARE\ADC;..\HARDWARE\SPBLCD;..\HARDWARE\I2S;..\HARDWARE\WM8978;..\MP3;..\MP3\helix
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/TPAD/: tpad.c
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c ott2001a.c touch.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/SPBLCD/: spblcd.c
    ../HARDWARE/I2S/: i2s.c
    ../HARDWARE/WM8978/: wm8978.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_rtc.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_pwr.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_rng.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_wwdg.c
  group README
    ../: readme.txt
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group GUI
    ../GUI/: button.c edit.c filelistbox.c gui.c listbox.c memo.c progressbar.c scrollbar.c window.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/exfuns/: fattester.c exfuns.c
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/src/option/: cc936.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group PICTURE
    ../PICTURE/: bmp.c gif.c piclib.c tjpgd.c
  group APP
    ../APP/: setting.c calendar.c display.c spb.c mynotice.c file.c alarm.c
  group MP3
    ../MP3/: mp3play.c
    ../MP3/helix/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c mp3dec.c mp3tabs.c scalfact.c stproc.c subband.c trigtabs.c
    ../MP3/helix/arm/: asmmisc_rvds.s asmpoly_thumb2_rvds.s
